## package/python-empy/Config.in
```kconfig
config BR2_PACKAGE_PYTHON_EMPY
	bool "python-empy"
	help
	  A templating system for Python.

	  http://www.alcyone.com/software/empy
```
